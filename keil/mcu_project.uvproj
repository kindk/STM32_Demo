# Keil uVision project mcu_project.uvproj, settings and files
target default (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mcu_project +hex
  AfterMake: fromelf.exe --bin -o @p.bin @p.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: ..\std_library\inc;..\std_library\core;..\code\app;..\code\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../code/app/: main.c proc.c
  group driver
    ../code/driver/: clk.c led.c mcu.c print.c utprt.c uart.c fifo.c key.c gpio.c
  group std_library
    ../std_library/core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c cpu_a.asm startup_stm32f10x_hd.s
    ../std_library/: STM32F103RCT6.lib
